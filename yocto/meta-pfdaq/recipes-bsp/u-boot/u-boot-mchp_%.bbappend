FILESEXTRAPATHS:prepend:mpfs-disco-kit-amp := "${THISDIR}/files:"
